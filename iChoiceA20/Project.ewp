# IAR project Project.ewp, settings and files
configuration STM32L152-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152x8 ST STM32L152x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ; BLE; User; Driver; LPSA; Task; Libraries\CMSIS\Device\ST\STM32L1xx\Include; Libraries\STM32L1xx_StdPeriph_Driver\inc; Libraries\USB_Driver\core\inc; Libraries\USB_Driver\API\inc; Utilities\STM32_EVAL; Utilities\STM32_EVAL\Common; Utilities\STM32_EVAL\STM32L152_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A20.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152D-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  OBJCOPY.OOCOutputFile: Project.srec
  group (top)
    ./: main.c
  group Driver
    Driver/: Battery.c Character.c Clock.c EEPROM.o Event.c Graphics.c IIC.o IIR.o InnerEEPROM.o key.c LIS3DH.c LPS331AP.c RTC.c System.c vbus.c
  group Driver/BLE
    BLE/: BLE.c BLE_COMM.c BLE_Command.c BLE_HCL.c
  group Driver/StdPeriph_Driver
    Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group Driver/USB_Driver/API
    Libraries/USB_Driver/API/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Driver/USB_Driver/core
    Libraries/USB_Driver/core/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group LPSA
    lpsa/: lpsa.c lpsa_queue.c lpsa_task.c lpsa_timer.c lpsa_wdt.c
  group System
    Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
    Driver/: stm32l1xx_it.c
    ./: system_stm32l1xx.c
  group Task
    task/: task_deepSleep.c task_sleep.c task_stop.c task_test.c task_tracker.c task_usb.c
  group User
    User/: ACCEL-SLEEP.h ACCEL-SLEEP.o ACCEL.h ACCEL.o ArrayQueue.h ArrayQueue.o Calculate.c Calculate.h CommandManager.h CommandManager.o Configuration.c Configuration.h DataSave.h DataSave.o Display.c Display.h RSA.h RSA.o TimeManage.h TimeManage.o Upload.c Upload.h
